# Keil uVision project stm32f407_bt_oled.uvprojx, settings and files
target STM32F407_BT_OLED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: stm32f407_bt_oled +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Core\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: RAM 0x20000000 size 0x20000
  memory RVCT9: ROM 0x8000000 size 0x80000
  scatter file: .\stm32f407.sct
  group Application
    ../Core/Src/: board_app.c route_fsm.c action_fsm.c mission_fsm.c turn_right.c vision_data.c maxicam.c zlis2_driver.c arm_control.c arm_kinematics.c arm_collision.c arm_tuner.c arm_trim.c arm_trim_bluetooth.c arm_trim_bench.c servo_pose.c servo_remote.c pid_tuner.c serial_io.c bluetooth_driver.c emm42_driver.c mecanum.c mecanum_test.c motor_driver.c car_control.c main.c jy61.c heading_control.c usart2_dma.c uart_bridge.c x42.c ssd1306.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group CMSIS Startup
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32 HAL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c
  group Headers
    ../Core/Inc/: main.h detect_data.h usart6_config.h route_fsm.h action_fsm.h turn_right.h turn_config.h vision_data.h vision_config.h maxicam.h pid_tuner.h zlis2_driver.h arm_config.h arm_control.h arm_kinematics.h arm_tuner.h servo_pose.h servo_pose_config.h servo_remote.h servo_remote_config.h ssd1306.h stm32f4xx_hal_conf.h
  group Project documentation
    ../: README.md
    ./: stm32f407.sct
